# Keil uVision project project.uvprojx, settings and files
target Qitas (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F205RBTx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: qitas
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F2XX
  c misc: --cpp
  c include: .\inc;.\lib\API\inc;.\lib\CMSIS\Device\ST\STM32F0xx\Include;.\lib\STM32F2\inc;.\lib\MISC\inc;.\lib\CMSIS\Include;.\lib\CMSIS\CM3\DeviceSupport\ST\STM32F2xx
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./src/: main.c
  group System
    ./src/: stm32f2xx_it.c
    ./inc/: stm32f2xx_it.h stm32f2xx_conf.h
  group CMSIS
    ./lib/CMSIS/CM3/DeviceSupport/ST/STM32F2xx/: startup_stm32f2xx.s system_stm32f2xx.c stm32f2xx.h
  group STM32F2
    ./lib/STM32F2/src/: misc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_cryp.c stm32f2xx_cryp_aes.c stm32f2xx_cryp_des.c stm32f2xx_cryp_tdes.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_hash.c stm32f2xx_hash_md5.c stm32f2xx_hash_sha1.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
  group API
    ./lib/API/src/: Common.c Delay.c Digital.cpp Analog.cpp Timer.cpp Systick.c I2C.cpp Serial.cpp SPI.cpp CAN.cpp
  group Misc
    ./lib/MISC/src/: average.cpp
